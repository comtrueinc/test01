# Keil uVision project ma2i.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: ma2i +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SUPPORT_IAP2=1
  c include: .\Inc
  group Source Group 1
    ./Common/: Main.c Mcu.c Descriptor.c Bulk.c Hid.c
    ./Interface/: Uart.c MI2C.c PeripheralCtrl.c SpiFlash.c Gpio.c
    ./Audio/: Entity.c Audio.c
    ./Iap2/: iap2_info.c iAP2.c
